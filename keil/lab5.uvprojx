# Keil uVision project lab5.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: CU_SYSC4906.LabF14_DFP.1.0.7
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab5
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM TM4C123GH6PM
  c include: .
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: UART_log.c delays.c padcontroller.c sensorinit.c main.cpp
    ./utils/: uartstdio.c
  group driverlib
    ./driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group sensorlib
    ./sensorlib/: ak8963.c ak8975.c bmp180.c bq27510g3.c cm3218.c comp_dcm.c i2cm_drv.c isl29023.c kxti9.c l3gd20h.c lsm303d.c lsm303dlhc_accel.c lsm303dlhc_mag.c magneto.c mpu6050.c mpu9150.c quaternion.c sht21.c tmp006.c tmp100.c vector.c
  group sensors
    ./: Sensor_LSM303.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
