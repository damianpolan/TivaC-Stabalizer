# Keil uVision project sensorlib.uvprojx, settings and files
target sensorlib (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: CU_SYSC4906.LabF14_DFP.1.0.7
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sensorlib (library)
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk
  c misc: --c99
  c include: ..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ak8963.c ak8975.c bmp180.c bq27510g3.c cm3218.c comp_dcm.c i2cm_drv.c isl29023.c kxti9.c l3gd20h.c lsm303d.c lsm303dlhc_accel.c lsm303dlhc_mag.c magneto.c mpu6050.c mpu9150.c quaternion.c sht21.c tmp006.c tmp100.c vector.c
  group Documentation
    ./: readme.txt
